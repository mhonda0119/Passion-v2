# Repository mhonda0119/Passion-v2

## EAGLE design Eagle/passion-v2-1/sensor-hub-lr.brd

Parts:
C3, C4: 0.1μ; C0603
C28, C29: C-EUC1206; C1206
CON1: B6B-ZR
J1: B8B-ZR(LF)(SN); JST_B8B-ZR(LF)(SN)
R9, R13: 10; R0603
R10, R14: 3.9k; R0603
R11, R15: 1k; R0603
R12, R16: 10k; R0603
T5, T7: 2N7002K; SOT23

Connections:
+3V3: CON1.1, CON1.6, J1.1, J1.7, R9.2, R13.2
GND: C28.2, C29.2, R10.1, R11.1, R12.1, R14.1, R15.1, R16.1, T5.2 (S), T7.2 (S)
IR_L: CON1.4, R12.2, T5.1 (G)
IR_L_A: C28.1, J1.5, R9.1
IR_L_K: J1.6, T5.3 (D)
IR_R: CON1.3, R16.2, T7.1 (G)
IR_R_A: C29.1, J1.3, R13.1
IR_R_K: J1.4, T7.3 (D)
SENSOR_L: C3.2, CON1.5, R10.2
SENSOR_L_E: C3.1, J1.8, R11.2
SENSOR_R: C4.2, CON1.2, R14.2
SENSOR_R_E: C4.1, J1.2, R15.2

Board: 4 copper layers, 20.0 x 10.0 mm, 16 parts (8 on the bottom side), 12 nets.

## EAGLE design Eagle/passion-v2-1/passion-v2-1.brd

Parts:
BAT1: PINHD-1X2; 1X02
BOOT: EG1215AA; SW_EG1215AA
C5, C12, C15, C17, C23: 2.2u; C0603
C6, C8, C11, C13, C20, C22, C33, C34: 0.1u; C0603
C7, C10: 10u; C0603
C9: 10u; C0603K
C14, C16: 0.33u; C0603
C21: 0.01u; C0603
C24: 0.47u; C0603
C25: 100u; C3216
D3, D4: SS13FL; SODFL3617X108N
EC-CON-L: B4B-ZR
EC-CON-R: B4B-ZR
FAN: JST-PH2
ICM20689: ICM-20689; QFN50P400X400X95-24N
J1: B10B-ZR(LF)(SN); JST_B10B-ZR(LF)(SN)
JP1: PINHD-2X3; 2X03
LED1, LED2, LED3, LED4, LED5-1, LED5-2, LED5-3, LED5-4, LED6-1, LED6-2, LED6-3, LED6-4, LED7: LEDCHIPLED_0603; CHIPLED_0603
MODE: TL6330AF200Q; SW_TL6330AF200Q
MOTOR_L: JST-PH2
MOTOR_R: JST-PH2
NJM2884-3V3, NJM2884-5V: I-10673_NJM2884U1-33; NJM2884U1-33
P-LED: LEDCHIPLED_0603; CHIPLED_0603
POWER: EG1215AA; SW_EG1215AA
R0: 0; R0603
R17, R18, R20, R22, R36, R37, R42: 10k; R0603
R19, R21, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35: 470; R0603
R23: 20k; R0603
R38, R39, R40, R41: 470; R0402
RESET: TL6330AF200Q; SW_TL6330AF200Q
SPK1: SMT-0540-S-R
STM32F405RGT6: STM32F405RGT6; QFP50P1200X1200X160-64N
T2: IRLR2905TRPBF; TO252-3
T4, T6, T9: 2N7002K; SOT23
TB6612: TB6612FNG(O,C,8,EL; SOP65P760X160-24N

Connections:
+3V3: BOOT.3, C8.1, C9.1, C10.2, C11.2, C17.1, C21.1, C22.1, C23.1, EC-CON-L.1, EC-CON-R.1, ICM20689.8 (VDDIO), ICM20689.13 (VDD), J1.1, JP1.6, NJM2884-3V3.4 (VOUT), POWER.3, R17.1, R21.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R38.2, R39.2, R40.2, R41.2, STM32F405RGT6.1 (VBAT), STM32F405RGT6.13 (VDDA), STM32F405RGT6.19 (VDD), STM32F405RGT6.32 (VDD), STM32F405RGT6.48 (VDD), STM32F405RGT6.64 (VDD), TB6612.20 (VCC)
+5V: C15.1, C16.1, D4.C, NJM2884-3V3.1 (CONTROL), NJM2884-3V3.5 (VIN), NJM2884-5V.4 (VOUT), SPK1.+ (-)
+8V: BAT1.2, C6.1, C7.1, C14.1, C20.1, C25.1, D3.C, FAN.1, NJM2884-5V.1 (CONTROL), NJM2884-5V.5 (VIN), R23.1, TB6612.13 (VM2), TB6612.14 (VM3), TB6612.24 (VM1)
BOOT0: BOOT.2, STM32F405RGT6.60 (BOOT0)
BUZZER: R36.2, STM32F405RGT6.57 (PB5), T9.1 (G)
CS: ICM20689.22 (NCS), STM32F405RGT6.54 (PD2)
EC_L_A: EC-CON-L.4, R41.1, STM32F405RGT6.58 (PB6)
EC_L_B: EC-CON-L.3, R40.1, STM32F405RGT6.59 (PB7)
EC_R_A: EC-CON-R.4, R39.1, STM32F405RGT6.37 (PC6)
EC_R_B: EC-CON-R.3, R38.1, STM32F405RGT6.38 (PC7)
FUN: R37.2, STM32F405RGT6.56 (PB4), T2.1 (G)
GND: C5.1, C8.2, C9.2, C10.1, C11.1, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C21.2, C22.2, C23.2, C24.2, EC-CON-L.2, EC-CON-R.2, ICM20689.11 (FSYNC), ICM20689.18 (GND), J1.2, JP1.1, LED1.C, LED2.C, LED3.C, LED4.C, LED7.C, MODE.3, MODE.4, NJM2884-3V3.2 (GND), NJM2884-5V.2 (GND), P-LED.C, R0.1, R18.1, R20.1, R22.2, R36.1, R42.1, RESET.3, RESET.4, STM32F405RGT6.12 (VSSA), STM32F405RGT6.18 (VSS), STM32F405RGT6.63 (VSS), T4.2 (S), T6.2 (S), T9.2 (S)
GND2: BAT1.1, C6.2, C7.2, C25.2, R0.2, R37.1, T2.3 (S), TB6612.3 (PGND1), TB6612.4 (PGND1), TB6612.9 (PGND2), TB6612.10 (PGND2), TB6612.18 (GND)
IR_FL: J1.9, STM32F405RGT6.4 (PC15/OSC32_OUT)
IR_FR: J1.7, STM32F405RGT6.6 (PH1/OSC_OUT)
IR_L: J1.10, STM32F405RGT6.3 (PC14/OSC32_IN)
IR_R: J1.8, STM32F405RGT6.5 (PH0/OSC_IN)
LED_1: R24.1, STM32F405RGT6.33 (PB12)
LED_2: R25.1, STM32F405RGT6.34 (PB13)
LED_3: R26.1, STM32F405RGT6.36 (PB15)
LED_4: R27.1, STM32F405RGT6.22 (PA6/SPI1_MISO)
LED_5: STM32F405RGT6.45 (PA12), T6.1 (G)
LED_6: STM32F405RGT6.44 (PA11), T4.1 (G)
LED_7: R19.1, STM32F405RGT6.50 (PA15)
MISO: ICM20689.9 (AD0/SDO), STM32F405RGT6.52 (PC11)
MOSI: ICM20689.24 (SDA/SDI), STM32F405RGT6.53 (PC12)
MOTOR_L_CCW: STM32F405RGT6.24 (PC4), TB6612.22 (AIN2)
MOTOR_L_CW: STM32F405RGT6.25 (PC5), TB6612.21 (AIN1)
MOTOR_L_OUT1: C33.1, MOTOR_L.2, TB6612.1 (AO1), TB6612.2 (AO1)
MOTOR_L_OUT2: C33.2, MOTOR_L.1, TB6612.5 (AO2), TB6612.6 (AO2)
MOTOR_L_PWM: STM32F405RGT6.21 (PA5/SPI1_SCK), TB6612.23 (PWMA)
MOTOR_R_CCW: STM32F405RGT6.29 (PB10), TB6612.16 (BIN2)
MOTOR_R_CW: STM32F405RGT6.27 (PB1), TB6612.17 (BIN1)
MOTOR_R_OUT1: C34.2, MOTOR_R.1, TB6612.11 (BO1), TB6612.12 (BO1)
MOTOR_R_OUT2: C34.1, MOTOR_R.2, TB6612.7 (BO2), TB6612.8 (BO2)
MOTOR_R_PWM: STM32F405RGT6.30 (PB11), TB6612.15 (PWMB)
MOTOR_STBY: STM32F405RGT6.26 (PB0), TB6612.19 (STBY)
unnamed: C5.2, STM32F405RGT6.47 (VCAP_2)
unnamed: C12.2, STM32F405RGT6.31 (VCAP_1)
unnamed: R18.2, STM32F405RGT6.28 (PB2/BOOT1)
unnamed: LED5-2.A, R29.2
unnamed: LED5-3.A, R30.2
unnamed: LED5-4.A, R31.2
unnamed: BOOT.1, R20.2
unnamed: C24.1, ICM20689.10 (REGOUT)
unnamed: P-LED.A, R21.2
unnamed: C20.2, D3.A, FAN.2, T2.2 (D), T2.PAD (D)
unnamed: D4.A, SPK1.- (+), T9.3 (D)
unnamed: LED6-2.A, R33.2
unnamed: LED1.A, R24.2
unnamed: LED6-3.A, R34.2
unnamed: LED6-4.A, R35.2
unnamed: POWER.1, R42.2
unnamed: LED4.A, R27.2
unnamed: LED5-1.A, R28.2
unnamed: LED7.A, R19.2
unnamed: LED2.A, R25.2
unnamed: LED6-1.C, LED6-2.C, LED6-3.C, LED6-4.C, T4.3 (D)
unnamed: LED5-1.C, LED5-2.C, LED5-3.C, LED5-4.C, T6.3 (D)
unnamed: LED3.A, R26.2
unnamed: LED6-1.A, R32.2
PC_RX: JP1.2, STM32F405RGT6.42 (PA9)
PC_TX: JP1.4, STM32F405RGT6.43 (PA10)
PUSH_IN_1: MODE.1, MODE.2, R17.2, STM32F405RGT6.9 (PC1)
PUSH_IN_3: STM32F405RGT6.11 (PC3/SPI2_MOSI)
RESET: C13.2, RESET.1, RESET.2, STM32F405RGT6.7 (NRST)
SCK: ICM20689.23 (SCL/SCLK), STM32F405RGT6.51 (PC10)
SENSOR_FL: J1.4, STM32F405RGT6.16 (PA2/USART2_TX)
SENSOR_FR: J1.6, STM32F405RGT6.14 (PA0/WKUP)
SENSOR_L: J1.3, STM32F405RGT6.17 (PA3/USART2_RX)
SENSOR_R: J1.5, STM32F405RGT6.15 (PA1/USART2_RTS)
SW-POWER: POWER.2, STM32F405RGT6.10 (PC2/SPI2_MISO)
SWCL: JP1.3, STM32F405RGT6.49 (PA14/JTCK-SWCLK)
SWDIO: JP1.5, STM32F405RGT6.46 (PA13/JMS-SWDIO)
VOL_CHECK: R22.1, R23.2, STM32F405RGT6.8 (PC0)

Notes on the sheet:
マイコン
インターフェース他
モータ系
センサ系
IMU

Board: 4 copper layers, 56.5 x 71.5 mm, 86 parts (47 on the bottom side), 74 nets.

## EAGLE design Eagle/passion-v2-1/sensor-hub-fr-fl.brd

Parts:
C1, C2: 0.1μ; C0603
C26, C27: C-EUC1206; C1206
CON1: B6B-ZR
J1: B8B-ZR(LF)(SN); JST_B8B-ZR(LF)(SN)
J3: B10B-ZR(LF)(SN); JST_B10B-ZR(LF)(SN)
R1, R5: 10; R0603
R2, R8: 10k; R0603
R3, R6: 3.9k; R0603
R4, R7: 470; R0603
T1, T3: 2N7002K; SOT23

Connections:
+3V3: CON1.1, CON1.6, J1.1, J1.8, J3.1, R1.2, R5.2
GND: C26.2, C27.2, J3.2, R2.1, R3.1, R4.1, R6.1, R7.1, R8.1, T1.2 (S), T3.2 (S)
IR_FL: J3.9, R2.2, T1.1 (G)
IR_FL_A: C26.1, J1.5, R1.1
IR_FL_K: J1.6, T1.3 (D)
IR_FR: J3.7, R8.2, T3.1 (G)
IR_FR_A: C27.1, J1.3, R5.1
IR_FR_K: J1.4, T3.3 (D)
IR_L: CON1.4, J3.10
IR_R: CON1.3, J3.8
SENSOR_FL: C2.2, J3.4, R3.2
SENSOR_FL_E: C2.1, J1.7, R4.2
SENSOR_FR: C1.2, J3.6, R6.2
SENSOR_FR_E: C1.1, J1.2, R7.2
SENSOR_L: CON1.5, J3.3
SENSOR_R: CON1.2, J3.5

Board: 4 copper layers, 22.0 x 15.0 mm, 17 parts (10 on the bottom side), 16 nets.

## Code that names these connections

File CubeMX/passion-v2-1/passion-v2-1.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=SENSOR_FR
PA0-WKUP.Signal=ADCx_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=SENSOR_R
PA1.Signal=ADCx_IN1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=PC_TX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=LED_6
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=LED_5
PA12.Signal=GPIO_Output
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=SWDIO
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=SWCL
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=LED_7
PA15.Signal=GPIO_Output
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=SENSOR_FL
PA2.Signal=ADCx_IN2
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=SENSOR_L
PA3.Signal=ADCx_IN3
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=MOTOR_L_PWM
PA5.Signal=S_TIM2_CH1_ETR
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=LED_4
PA6.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=PC_RX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=MOTOR_STBY
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=MOTOR_R_CW
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=MOTOR_R_CCW
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=MOTOR_R_PWM
PB11.Signal=S_TIM2_CH4
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=LED_1
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=LED_2
PB13.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=LED_3
PB15.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=FAN
PB4.Signal=S_TIM3_CH1
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=BUZZER
PB5.Signal=S_TIM3_CH2
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=EC_L_A
PB6.Signal=S_TIM4_CH1
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=EC_L_B
PB7.Signal=S_TIM4_CH2
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=VOL_CHECK
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=PUSH_IN_1
PC1.Signal=GPIO_Input
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=SCK
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=MISO
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.GPIOParameters=GPIO_Label
PC12.GPIO_Label=MOSI
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=IR_L
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=IR_FL
PC15-OSC32_OUT.Signal=GPIO_Output
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=SW_POWER
PC2.Signal=GPIO_Input
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=PUSH_IN_3
PC3.Signal=GPIO_Input
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=MOTOR_L_CCW
PC4.Signal=GPIO_Input
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=MOTOR_L_CW
PC5.Signal=GPIO_Input
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=EC_R_A
PC6.Signal=S_TIM8_CH1
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=EC_R_B
PC7.Signal=S_TIM8_CH2
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=CS
PD2.Signal=GPIO_Output
PH0-OSC_IN.GPIOParameters=GPIO_Label
PH0-OSC_IN.GPIO_Label=IR_R
PH0-OSC_IN.Signal=GPIO_Output
PH1-OSC_OUT.GPIOParameters=GPIO_Label
PH1-OSC_OUT.GPIO_Label=IR_FR
PH1-OSC_OUT.Signal=GPIO_Output
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom
